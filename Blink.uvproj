# Keil uVision project Blink.uvproj, settings and files
target Target 1 (MCS-51)
  device: R80515 Cadence Design Systems Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MODC2 MDU_R515
  output: Blink +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Blink.a51
